# Keil uVision project SL58128_MiniSys.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SC32F58128 SILAN
  pack: SILAN.SC32F58xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GeneralMotorCtrl
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MOTOR_AXIS = 1
  c misc: --diag_suppress=1 --diag_suppress=177 --diag_suppress=550
  c include: .\include\drive\BSP;.\include\drive\M0DRV;.\include\drive\HAL;.\include\lib;.\include\pfc;.\include\user;.\include\lib\math_blocks\v4.0;.\include\drive\HAL;.\include\motorLib;.\include\Hisense_Leovel0_include\common;.\source\FreeRTOS-Kernel\portable\RVDS\ARM_CM0;.\source\FreeRTOS-Kernel\include;.\source\FreeRTOS-Plus-CLI;.\source\drive\Inc;.\source\User
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./source/User/: UserConfig.h SL_main.c SL_niv.c MowerFSM.c MowerFSM.h MotorSpeedCalc.c UartToMotor.c UartToWifi.c UartToPanel .c Boundary.c SampleInfo.c ErrCode.h Protect.c Fault.c f_FuncCode.c f_FuncCode.h Control&Filter.c Control&Filter.h QMI8658C_IIC.c f_uart0.c
  group UI_Lib
    ./source/lib/: OSC.lib
  group driver/BSP
    ./source/drive/BSP/: devInit.c BSP_gpio.c BSP_dma.c BSP_uart.c BSP_adc.c BSP_pwm.c BSP_iic.c
  group CommonLib
    ./source/drive/HAL/: timer4Tick.c
  group FreeRTOS/src
    ./source/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ./source/FreeRTOS-Kernel/portable/RVDS/ARM_CM0/: port.c
    ./source/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group FreeRTOS/CLI
    ./source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c Sample-CLI-commands.c UARTCommandConsole.c serial.c
target release (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: SC32F58128 SILAN
  pack: SILAN.SC32F58xx_DFP.1.4.0
  cpu: as above
  output: GeneralMotorCtrl
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MOTOR_AXIS = 1
  c misc: --diag_suppress=1 --diag_suppress=177 --diag_suppress=550
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.1.0, Device:Driver:ADC 1.0.0, Device:Driver:CAN 1.0.0, Device:Driver:CMPSS 1.0.0, Device:Driver:DMA 1.0.0, Device:Driver:GPIO 1.0.0, Device:Driver:IAP 1.0.0, Device:Driver:IIC 1.0.0, Device:Driver:PWM 1.0.0, Device:Driver:QEP 1.0.0, Device:Driver:SPI 1.0.0, Device:Driver:SystemClock 1.0.0, Device:Driver:TIMER 1.0.0, Device:Driver:UART 1.0.0, Device:Driver:WDT 1.0.0, Device:Startup 1.0.0
